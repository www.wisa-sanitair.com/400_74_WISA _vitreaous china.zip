Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2015-03-26T12:02:35
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 26 12:02:35 2015 * Host: PC-ARN-001 * Database: C:\Users\mdegans\AppData\Local\Temp\{168BA631-F91A-49CB-BA93-7D567B9F9C5D}\ifc * Database version: 5507 * Database creation date: Thu Mar 26 12:02:32 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 26 12:02:32 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 26 12:02:32 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\Revit 2014\02-Te controleren\Bibliotheken\Engels\IFC\400_74_WISA _vitreaous china.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Color: 0; Symbol at End 2 Default: yes; Line Pattern: -3000010
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no

# IfcBuildingElementProxy: Model Text:Model Text 1
In: Level 1
Graphics - Text: VITREOUS CHINA; Horizontal Align: Left
Identity Data - Subcategory: -2000151
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Phasing - Phase Created: New Construction
Materials and Finishes - Material: WISA zwart
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Text - Italic: no; Bold: no; Text Size: 600 mm; Text Font: Arial

# IfcBuildingElementProxy: Model Text:Model Text 2
In: Level 1
Dimensions - Depth: 50 mm
Constraints - Work Plane: Level : Level 1
Graphics - Horizontal Align: Left; Text: VITREAOUS CHINA
Identity Data - Subcategory: -2000151
Materials and Finishes - Material: WISA zwart
Phasing - Phase Created: New Construction
Pset_BuildingElementProxyCommon - Reference: Model Text 2
Text - Text Size: 400 mm; Bold: no; Italic: no; Text Font: Arial

# IfcBuildingElementProxy: Model Text:Model Text 3 (6)
In: Level 1
Dimensions - Depth: 50 mm
Constraints - Work Plane: Level : Level 1
Phasing - Phase Created: New Construction
Identity Data - Subcategory: -2000151
Graphics - Horizontal Align: Left
Materials and Finishes - Material: WISA zwart
Pset_BuildingElementProxyCommon - Reference: Model Text 3
Text - Text Size: 200 mm; Text Font: Arial; Italic: no; Bold: no
Name (Model Text:...) | Text
Model Text 3 | WALL HANGING CLOSETS
Model Text 3 | STANDING CLOSETS
Model Text 3 | URINAL
Model Text 3 | BIDET
Model Text 3 | WASHBASINS
Model Text 3 | OTHER

# IfcFlowTerminal: bidet_wisa_sydney bidet, RSen_74_PF_FB_bidet sydney_wisa:bidet_wisa_sydney bidet:3788616
In: Level 1
Type - ElementType: bidet_wisa_sydney bidet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Identity Data - Mark: 1706; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM: EC010126; Rsen_C_code_manufacturer_product: 9100901796; NLRS_C_revit_versie: 2014; Rsen_C_type_comments: Bidet; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.10); URL: www.wisa-sanitair.com/nl/9100901796; Rsen_C_description: WISA Sydney bidet; Rsen_C_model: Sydney; Rsen_C_code_gtin: 8711778158313; Model: Sydney; Rsen_C_code_SfB_table1: 74.10; Type Comments: Bidet; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010126&ArtClassVersion=4; Description: WISA Sydney bidet
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_depth: 525 mm; Rsen_C_height: 350 mm; Rsen_C_width: 355 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Mechanical - WFU: 0; CWFU: 0

# IfcFlowTerminal: inlet above_wisa_sydney urinal, RSen_74_PF_FB_urinal inlet above sydney_wisa:inlet above_wisa_sydney urinal:3788463
In: Level 1
Type - ElementType: inlet above_wisa_sydney urinal; PredefinedType: URINAL; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Identity Data - Mark: 1704; Rsen_C_code_ETIM: EC010235; Rsen_C_description: WISA Sydney urinoir boveninlaat; URL: www.wisa-sanitair.com/nl/9100901790; Model: Sydney; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010235&ArtClassVersion=5; Rsen_C_code_gtin: 8711778158252; Type Comments: Urinal; Rsen_C_model: Sydney; Assembly Code: 4A(74.10); Manufacturer: WISA; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 9100901790; Rsen_C_type_comments: Urinoir; Description: WISA Sydney urinal inlet above; NLRS_C_revit_versie: 2014; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - CWFU: 0; WFU: 0
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_height: 575 mm; Rsen_C_width: 365 mm; Rsen_C_depth: 350 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white

# IfcFlowTerminal: inlet behind_wisa_urinal, RSen_74_PF_FB_urinal inlet behind sydney_wisa:inlet behind_wisa_urinal:3788553
In: Level 1
Type - ElementType: inlet behind_wisa_urinal; PredefinedType: URINAL; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Identity Data - Mark: 1705; Manufacturer: WISA; Assembly Code: 4A(74.10); Assembly Description: algemeen (verzamelniveau); Rsen_C_type_comments: Urinal; Rsen_C_code_gtin: 8711778158269; Rsen_C_code_ETIM: EC010235; Description: WISA Sydney urinal inlet behind; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Type Comments: Urinal; NLRS_C_revit_versie: 2014; URL: www.wisa-sanitair.com/nl/9100901791; Rsen_C_model: Sydney; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010235&ArtClassVersion=5; Rsen_C_description: WISA Sydney urinal inlet behind; Model: Sydney; Rsen_C_code_manufacturer_product: 9100901791
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Dimensions - Rsen_C_width: 365 mm; Rsen_C_height: 575 mm; Rsen_C_depth: 350 mm
General - Rsen_C_content_creator: WISA
Mechanical - CWFU: 0; WFU: 0

# IfcFlowTerminal: pergamon_wisa_fountain 40cm, RSen_74_PF_FB_fountain 40 cm_wisa:pergamon_wisa_fountain 40cm:3788773
In: Level 1
Type - ElementType: pergamon_wisa_fountain 40cm; PredefinedType: SANITARYFOUNTAIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - country_index: 1; Schedule Level: Level: Level 1
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Dimensions - Rsen_C_width: 395 mm; Rsen_C_height: 130 mm; Rsen_C_depth: 270 mm
Mechanical - CWFU: 0; WFU: 0
Identity Data - URL: www.wisa-sanitair.com/nl/9100901716; Manufacturer: WISA; Rsen_C_code_SfB_table1: 74.10; Type Comments: Fountain; Description: WISA Sydney fountain 40 cm pergamon; Rsen_C_model: Sydney; Rsen_C_description: WISA Sydney fontein 40 cm pergamon; Model: Sydney; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Rsen_C_code_gtin: 8711778116504; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_STABU: 53.31; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.10); Rsen_C_type_comments: Fontein; Rsen_C_code_ETIM: EC011550; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 9100901716; Mark: 1708
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: pergamon_wisa_sydney siphon cover, RSen_74_PF_FB_siphon cover_wisa:pergamon_wisa_sydney siphon cover:3790420
In: Level 1
Type - ElementType: pergamon_wisa_sydney siphon cover; PredefinedType: USERDEFINED; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: NLRS_n6_PEXa_pergamon
Other - country_index: 1; Schedule Level: Level: Level 1
Mechanical - WFU: 0; CWFU: 0
Materials and Finishes - Rsen_C_material: NLRS_n6_PEXa_pergamon
Dimensions - Rsen_C_height: 306 mm; Rsen_C_depth: 295 mm; Rsen_C_width: 180 mm
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Identity Data - Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_gtin: 8711778116481; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_product: 9100901714; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Description: Siphon cover for WISA Sydney Washbasin pergamon; Rsen_C_model: Sydney; Model: Sydney; Assembly Code: 4A(74.22); Rsen_C_code_ETIM: EC011331; Rsen_C_description: Siphon cover for WISA Sydney Washbasin pergamon; NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011331&ArtClassVersion=4; URL: www.wisa-sanitair.com/nl/9100901714; Rsen_C_type_comments: Siphon cover; Type Comments: Siphon cover; Mark: 1716
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: pergamon_wisa_sydney washbasin, RSen_74_PF_FB_washbasin sydney 60cm_wisa:pergamon_wisa_sydney washbasin:3790161
In: Level 1
Type - ElementType: pergamon_wisa_sydney washbasin; PredefinedType: WASHHANDBASIN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - country_index: 1; siphon cover_white: no; Schedule Level: Level: Level 1; siphon cover_pergamon: no
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
General - Rsen_C_content_creator: WISA
Identity Data - Rsen_C_description: WISA Sydney Washbasin 60 cm pergamon; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 9100901710; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_gtin: 8711778116443; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_ETIM: EC011550; Model: Sydney; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.22); Description: WISA Sydney Washbasin 60 cm pergamon; URL: www.wisa-sanitair.com/nl/9100901710; Type Comments: Washbasin; Rsen_C_code_STABU: 53.31; Rsen_C_type_comments: Wastafel; Rsen_C_model: Sydney; Rsen_C_code_SfB_table1: 74.10; Mark: 1712
Mechanical - WFU: 0; CWFU: 0
Dimensions - Rsen_C_height: 200 mm; Rsen_C_width: 600 mm; Rsen_C_depth: 445 mm
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Phasing - Phase Created: New Construction
Model Properties - siphon cover: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: platform ao_wisa_sydney standing closet, RSen_74_PF_FB_standing closet platform ao sydney_wisa:platform ao_wisa_sydney standing closet:3788146
In: Level 1
Type - ElementType: platform ao_wisa_sydney standing closet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Mechanical - System Classification: Sanitary; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Constraints - Elevation: 0 mm; Host: Level : Level 1; Default Elevation: 0 mm
Identity Data - Mark: 1701; Rsen_C_model: Sydney; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: WISA Sydney standing closet AO platform; Rsen_C_code_STABU: 53.31; Model: Sydney; Rsen_C_code_ETIM: EC011289; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Type Comments: Standing closet; Rsen_C_code_gtin: 8711778119994; Manufacturer: WISA; Rsen_C_type_comments: Staand closet; Rsen_C_code_manufacturer_product: 9100901741; NLRS_C_revit_versie: 2014; Description: WISA Sydney standing closet AO platform; Assembly Code: 4A(74.10); URL: www.wisa-sanitair.com/nl/9100901741
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Dimensions - Rsen_P_c01_diameter: 100 mm; Rsen_C_height: 395 mm; Rsen_C_depth: 465 mm; Rsen_C_width: 355 mm
General - Rsen_C_content_creator: WISA
Text - Rsen_P_c01_definition: c01_sewage
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white

# IfcFlowTerminal: platform pk_wisa_sydney standing closet, RSen_74_PF_FB_standing closet platform pk sydney_wisa:platform pk_wisa_sydney standing closet:3787891
In: Level 1
Type - ElementType: platform pk_wisa_sydney standing closet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Mechanical - System Classification: Sanitary; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Identity Data - Mark: 1698; Rsen_C_type_comments: Standing closet; Assembly Description: algemeen (verzamelniveau); Model: Sydney; Rsen_C_model: Sydney; Rsen_C_code_manufacturer_product: 9100901706; Rsen_C_code_SfB_table1: 74.10; Type Comments: Standing closet; Rsen_C_code_ETIM: EC011289; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.10); Rsen_C_code_gtin: 8711778116429; Rsen_C_code_manufacturer_gln: 8711778000001; Description: WISA Sydney standing closet PK platform; Rsen_C_description: WISA Sydney staand closet PK vlakspoel; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; URL: www.wisa-sanitair.com/nl/9100901706; Rsen_C_code_STABU: 53.31; Manufacturer: WISA
Constraints - Elevation: 0 mm; Host: Level : Level 1; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_P_c01_definition: c01_sewage
Dimensions - Rsen_P_c01_diameter: 100 mm; Rsen_C_depth: 460 mm; Rsen_C_height: 395 mm; Rsen_C_width: 355 mm
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white

# IfcFlowTerminal: platform_wisa_sydney wall closet, RSen_74_PF_FB_wall closet platform sydney_wisa:platform_wisa_sydney wall closet:3787697
In: Level 1
Type - ElementType: platform_wisa_sydney wall closet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Identity Data - Mark: 1696; Rsen_C_type_comments: Wall closet; NLRS_C_revit_versie: 2014; Manufacturer: WISA; Rsen_C_code_STABU: 53.31; Rsen_C_code_gtin: 8711778158207; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_model: Sydney; Type Comments: Wall closet; Description: WISA Sydney wall closet platform; Assembly Description: algemeen (verzamelniveau); Rsen_C_description: WISA Sydney wall closet platform; URL: www.wisa-sanitair.com/nl/9100901785; Model: Sydney; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Assembly Code: 4A(74.10); Rsen_C_code_manufacturer_product: 9100901785; Rsen_C_code_ETIM: EC011289
Phasing - Phase Created: New Construction
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Mechanical - CWFU: 0; WFU: 0
Dimensions - Rsen_C_width: 355 mm; Rsen_C_height: 350 mm; Rsen_C_depth: 525 mm
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: standard ao_wisa_sydney standing toilet, RSen_74_PF_FB_standing closet standard ao sydney_wisa:standard ao_wisa_sydney standing toilet:3788320
In: Level 1
Type - ElementType: standard ao_wisa_sydney standing toilet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Identity Data - Mark: 1703; Rsen_C_description: WISA Sydney standing closet AO standard; Rsen_C_code_SfB_table1: 74.10; URL: www.wisa-sanitair.com/nl/9100901788; Description: WISA Sydney standing closet AO standard; Rsen_C_code_manufacturer_product: 9100901788; Rsen_C_model: Sydney; Rsen_C_code_ETIM: EC011289; Rsen_C_code_STABU: 53.31; Rsen_C_code_gtin: 8711778158238; Rsen_C_type_comments: Staand closet; Assembly Description: algemeen (verzamelniveau); NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Rsen_C_code_manufacturer_gln: 8711778000001; Model: Sydney; Assembly Code: 4A(74.10); Type Comments: Standing closet; Manufacturer: WISA
Mechanical - System Classification: Sanitary; CWFU: 0; Rsen_P_c01_fixture units: 0; WFU: 0
Constraints - Elevation: 0 mm; Host: Level : Level 1; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Dimensions - Rsen_C_height: 395 mm; Rsen_C_depth: 465 mm; Rsen_P_c01_diameter: 100 mm; Rsen_C_width: 355 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Text - Rsen_P_c01_definition: c01_sewage
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: standard pk_wisa_sydney raised standing toilet, RSen_74_PF_FB_standing closet raised standard pk sydney_wisa:standard pk_wisa_sydney raised standing toilet:3788043
In: Level 1
Type - ElementType: standard pk_wisa_sydney raised standing toilet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Constraints - Host: Level : Level 1; Elevation: 0 mm; Default Elevation: 0 mm
Identity Data - Mark: 1700; Type Comments: Standing closet; URL: www.wisa-sanitair.com/nl/9100901744; Rsen_C_description: WISA Sydney standing closet raised PK standard; Manufacturer: WISA; Rsen_C_type_comments: Standing closet; Rsen_C_code_gtin: 8711778124981; Model: Sydney; Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_ETIM: EC011289; Description: WISA Sydney standing closet raised PK standard; Rsen_C_model: Sydney; Assembly Code: 4A(74.10); Assembly Description: algemeen (verzamelniveau); NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_product: 9100901744; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4
Mechanical - System Classification: Sanitary; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_P_c01_definition: c01_sewage
Dimensions - Rsen_C_height: 460 mm; Rsen_C_depth: 460 mm; Rsen_C_width: 355 mm; Rsen_P_c01_diameter: 100 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: standard pk_wisa_sydney standing toilet, RSen_74_PF_FB_standing closet standard pk sydney_wisa:standard pk_wisa_sydney standing toilet:3788261
In: Level 1
Type - ElementType: standard pk_wisa_sydney standing toilet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Mechanical - System Classification: Sanitary; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Constraints - Elevation: 0 mm; Host: Level : Level 1; Default Elevation: 0 mm
Identity Data - Mark: 1702; Assembly Description: algemeen (verzamelniveau); Model: Sydney; Rsen_C_model: Sydney; Rsen_C_type_comments: Standing closet; Rsen_C_code_manufacturer_product: 9100901702; NLRS_C_revit_versie: 2014; Type Comments: Standing closet; Rsen_C_code_SfB_table1: 74.10; URL: www.wisa-sanitair.com/nl/9100901702; Description: WISA Sydney standing closet PK standard; Assembly Code: 4A(74.10); Manufacturer: WISA; Rsen_C_code_gtin: 8711778115262; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Rsen_C_description: WISA Sydney standing closet PK standard; Rsen_C_code_ETIM: EC011289; Rsen_C_code_STABU: 53.31
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Text - Rsen_P_c01_definition: c01_sewage
Dimensions - Rsen_P_c01_diameter: 100 mm; Rsen_C_width: 355 mm; Rsen_C_height: 395 mm; Rsen_C_depth: 460 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white

# IfcFlowTerminal: standard_wisa_medica wall closet, RSen_74_PF_FB_wall closet standard medica_wisa:standard_wisa_medica wall closet:3787739
In: Level 1
Type - ElementType: standard_wisa_medica wall closet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Identity Data - Mark: 1697; Rsen_C_code_SfB_table1: 74.10; Manufacturer: WISA; Rsen_C_type_comments: Wandcloset; Rsen_C_code_gtin: 8711778125063; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Assembly Description: algemeen (verzamelniveau); Rsen_C_description: WISA Medica wandcloset 70 cm; Rsen_C_code_manufacturer_product: 9100901946; Rsen_C_code_ETIM: EC011289; Description: WISA Medica wall closet 70 cm; Assembly Code: 4A(74.10); NLRS_C_revit_versie: 2014; Model: Medica; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Rsen_C_model: Medica; Type Comments: Wall closet; URL: www.wisa-sanitair.com/nl/9100901946
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Dimensions - Rsen_C_width: 355 mm; Rsen_C_depth: 700 mm; Rsen_C_height: 335 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Mechanical - CWFU: 0; WFU: 0
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: standard_wisa_sydney wall closet, RSen_74_PF_FB_wall closet standard sydney_wisa:standard_wisa_sydney wall closet:3787594
In: Level 1
Type - ElementType: standard_wisa_sydney wall closet; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Identity Data - Mark: 1695; Rsen_C_description: WISA Sydney wandcloset diepspoel; Rsen_C_code_ETIM: EC011289; Rsen_C_code_SfB_table1: 74.10; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_gtin: 8711778117280; Rsen_C_code_manufacturer_product: 9100901701; Manufacturer: WISA; Rsen_C_model: Sydney; Type Comments: Wall closet; URL: www.wisa-sanitair.com/nl/9100901701; Rsen_C_type_comments: Wandcloset; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.10); Description: WISA Sydney wall closet standard; Model: Sydney; Rsen_C_code_STABU: 53.31
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Dimensions - Rsen_C_width: 355 mm; Rsen_C_depth: 525 mm; Rsen_C_height: 350 mm
Mechanical - CWFU: 0; WFU: 0
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: white_wisa_shelf, RSen_74_PF_FB_shelf_wisa:white_wisa_shelf:3790460
In: Level 1
Type - ElementType: white_wisa_shelf; PredefinedType: USERDEFINED; Classification: 4A(74.13) accessoires (UniFormat); Material: RSen_g3_porcelain_white
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_width: 640 mm; Rsen_C_depth: 150 mm; Rsen_C_height: 90 mm
Identity Data - Assembly Description: accessoires; URL: www.wisa-sanitair.com/nl/9100901724; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011163&ArtClassVersion=5; NLRS_C_revit_versie: 2014; Rsen_C_model: Universeel; Manufacturer: WISA; Rsen_C_type_comments: Shelf; Rsen_C_code_SfB_table1: 74.13; Rsen_C_code_gtin: 8711778116580; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: WISA Keramisch planchet; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC011163; Rsen_C_code_manufacturer_product: 9100901724; Type Comments: Shelf; Assembly Code: 4A(74.13); Description: WISA ceramic shelf; Model: Universal; Mark: 1717
Mechanical - CWFU: 0; WFU: 0
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_sydney fountain 40 cm, RSen_74_PF_FB_fountain 40 cm_wisa:white_wisa_sydney fountain 40 cm:3788722
In: Level 1
Type - ElementType: white_wisa_sydney fountain 40 cm; PredefinedType: SANITARYFOUNTAIN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_g3_porcelain_white
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Phasing - Phase Created: New Construction
Identity Data - Mark: 1707; Rsen_C_code_ETIM: EC011550; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA Sydney fontein 40 cm wit; Rsen_C_code_gtin: 8711778116498; Rsen_C_model: Sydney; Assembly Code: 4A(74.22); Model: Sydney; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_product: 9100901715; Rsen_C_type_comments: Fontein; URL: www.wisa-sanitair.com/nl/9100901715; Description: WISA Sydney fountain 40 cm white; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Type Comments: Fountain
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1; country_index: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Dimensions - Rsen_C_height: 130 mm; Rsen_C_depth: 270 mm; Rsen_C_width: 395 mm
General - Rsen_C_content_creator: WISA
Mechanical - WFU: 0; CWFU: 0

# IfcFlowTerminal: white_wisa_sydney fountain 50 cm, RSen_74_PF_FB_fountain 50 cm_wisa:white_wisa_sydney fountain 50 cm:3789969
In: Level 1
Type - ElementType: white_wisa_sydney fountain 50 cm; PredefinedType: SANITARYFOUNTAIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Dimensions - Rsen_C_depth: 410 mm; Rsen_C_height: 195 mm; Rsen_C_width: 505 mm
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Identity Data - Rsen_C_description: WISA Sydney fountain 50 cm white; Rsen_C_type_comments: Fontein; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; Rsen_C_code_gtin: 8711778158290; Assembly Code: 4A(74.10); Type Comments: Fountain; Rsen_C_code_ETIM: EC011550; Manufacturer: WISA; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_model: Sydney; Rsen_C_code_manufacturer_product: 9100901794; URL: www.wisa-sanitair.com/nl/9100901794; Model: Sydney; Description: WISA Sydney fountain 50 cm white; NLRS_C_revit_versie: 2014; Mark: 1709
General - Rsen_C_content_creator: WISA
Mechanical - WFU: 0; CWFU: 0
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_sydney siphon cover, RSen_74_PF_FB_siphon cover_wisa:white_wisa_sydney siphon cover:3790379
In: Level 1
Type - ElementType: white_wisa_sydney siphon cover; PredefinedType: USERDEFINED; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_g3_porcelain_white
General - Rsen_C_content_creator: WISA
Other - country_index: 0; Schedule Level: Level: Level 1
Dimensions - Rsen_C_depth: 295 mm; Rsen_C_height: 306 mm; Rsen_C_width: 180 mm
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Mechanical - CWFU: 0; WFU: 0
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Identity Data - Assembly Code: 4A(74.22); Rsen_C_model: Sydney; Manufacturer: WISA; Rsen_C_type_comments: Siphon cover; Rsen_C_code_ETIM: EC011331; Model: Sydney; Rsen_C_code_manufacturer_product: 9100901713; NLRS_C_revit_versie: 2014; URL: www.wisa-sanitair.com/nl/9100901713; Rsen_C_code_gtin: 8711778116474; Type Comments: Siphon cover; Rsen_C_code_STABU: 53.31; Description: Siphon cover for WISA Sydney Washbasin white; Rsen_C_code_SfB_table1: 74.10; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; Rsen_C_description: Siphon cover for WISA Sydney Washbasin white; Mark: 1715
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_sydney washbasin 55 cm, RSen_74_PF_FB_washbasin sydney 55cm_wisa:white_wisa_sydney washbasin 55 cm:3790039
In: Level 1
Type - ElementType: white_wisa_sydney washbasin 55 cm; PredefinedType: WASHHANDBASIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_width: 550 mm; Rsen_C_height: 185 mm; Rsen_C_depth: 420 mm
Mechanical - WFU: 0; CWFU: 0
Identity Data - URL: www.wisa-sanitair.com/nl/9100901707; Manufacturer: WISA; Rsen_C_type_comments: Wastafel; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; Type Comments: Washbasin; NLRS_C_revit_versie: 2014; Rsen_C_description: WISA Sydney Washbasin 55 cm white; Rsen_C_code_STABU: 53.31; Rsen_C_model: Sydney; Rsen_C_code_gtin: 8711778053632; Model: Sydney; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_gln: 8711778000001; Assembly Code: 4A(74.10); Rsen_C_code_ETIM: EC011550; Rsen_C_code_manufacturer_product: 9100901707; Description: WISA Sydney Washbasin 55 cm white; Mark: 1710
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Model Properties - siphon cover: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_sydney washbasin 60 cm, RSen_74_PF_FB_washbasin sydney 60cm_wisa:white_wisa_sydney washbasin 60 cm:3790125
In: Level 1
Type - ElementType: white_wisa_sydney washbasin 60 cm; PredefinedType: WASHHANDBASIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Dimensions - Rsen_C_depth: 445 mm; Rsen_C_width: 600 mm; Rsen_C_height: 200 mm
Other - country_index: 0; siphon cover_white: no; Schedule Level: Level: Level 1; siphon cover_pergamon: no
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Mechanical - WFU: 0; CWFU: 0
Identity Data - Rsen_C_model: Sydney; Rsen_C_code_manufacturer_product: 9100901709; Assembly Code: 4A(74.10); Assembly Description: algemeen (verzamelniveau); NLRS_C_revit_versie: 2014; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_gtin: 8711778053649; Rsen_C_code_ETIM: EC011550; Rsen_C_description: WISA Sydney Washbasin 60 cm white; Type Comments: Washbasin; Rsen_C_type_comments: Wastafel; Description: WISA Sydney Washbasin 60 cm white; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; URL: www.wisa-sanitair.com/nl/9100901709; Model: Sydney; Mark: 1711
Phasing - Phase Created: New Construction
Model Properties - siphon cover: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_sydney washbasin 65 cm, RSen_74_PF_FB_washbasin sydney 65cm_wisa:white_wisa_sydney washbasin 65 cm:3790198
In: Level 1
Type - ElementType: white_wisa_sydney washbasin 65 cm; PredefinedType: WASHHANDBASIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Mechanical - CWFU: 0; WFU: 0
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Identity Data - Rsen_C_model: Sydney; Rsen_C_code_ETIM: EC011550; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Manufacturer: WISA; Description: WISA Sydney Washbasin 65 cm white; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; Rsen_C_description: WISA Sydney wastafel 65 cm wit; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_gtin: 8711778116450; Rsen_C_code_manufacturer_product: 9100901711; Model: Sydney; Type Comments: Washbasin; Assembly Code: 4A(74.10); Assembly Description: algemeen (verzamelniveau); Rsen_C_type_comments: Washbasin; URL: www.wisa-sanitair.com/nl/9100901711; Mark: 1713
Dimensions - Rsen_C_height: 205 mm; Rsen_C_width: 650 mm; Rsen_C_depth: 490 mm
Phasing - Phase Created: New Construction
Model Properties - siphon cover: no
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_washbasin 60 cm, RSen_74_PF_FB_washbasin medica 60cm_wisa:white_wisa_washbasin 60 cm:3790258
In: Level 1
Type - ElementType: white_wisa_washbasin 60 cm; PredefinedType: WASHHANDBASIN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_g3_porcelain_white
Materials and Finishes - Rsen_C_material: RSen_g3_porcelain_white
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
General - Rsen_C_content_creator: WISA
Mechanical - WFU: 0; CWFU: 0
Dimensions - Rsen_C_width: 600 mm; Rsen_C_height: 200 mm; Rsen_C_depth: 510 mm
Identity Data - Model: Medica; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011550&ArtClassVersion=5; NLRS_C_revit_versie: 2014; Rsen_C_code_STABU: 53.31; Type Comments: Washbasin; Assembly Code: 4A(74.10); Manufacturer: WISA; Rsen_C_code_manufacturer_product: 9100901930; Rsen_C_code_gtin: 8711778125056; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_model: Medica; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_ETIM: EC011550; URL: www.wisa-sanitair.com/nl/9100901930; Rsen_C_type_comments: Washbasin; Description: WISA Medica washbasin 60 cm white; Rsen_C_description: WISA Medica wastafel 60 cm wit; Mark: 1714
Phasing - Phase Created: New Construction
Model Properties - siphon cover: no
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcMember: 74_WISA_logo, 74_WISA_logo:74_WISA_logo:2618254
In: Level 1
Type - ElementType: 74_WISA_logo; Classification:  (UniFormat); Material: WISA blauw
Constraints - Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 4.01625 ft3
Pset_MemberCommon - Reference: 74_WISA_logo; LoadBearing: yes; IsExternal: no; Span: 50 mm; Slope: 0 deg
